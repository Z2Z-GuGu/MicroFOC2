# Keil uVision project MicroFOC.uvprojx, settings and files
target MicroFOC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MM32F003NW MindMotion
  pack: MindMotion.MM32F003_DFP.1.0.3
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x800) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: MicroFOC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\lib\SVPWM;..\lib\Basic;..\lib\UART;..\main;..\device\MM32F003_q\HAL_lib\inc;..\device\MM32F003_q\Include;..\device\CMSIS\KEIL_CORE;..\lib\AS5600;..\lib\ADC;..\lib\SCIO;..\lib\Ctrl;..\app
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group MAIN
    ../main/: main.c
  group STARTUP
    C:/Users/mouji/Documents/Keil/MM32F003/Device/MM32F003_q/Source/: system_MM32F003_q.c
    C:/Users/mouji/Documents/Keil/MM32F003/Device/MM32F003_q/Source/KEIL_StartAsm/: startup_MM32F003_q.s
  group Library
    ../lib/ADC/: ADC.c
    ../lib/AS5600/: AS5600.c
    ../lib/Basic/: Basic.c
    ../lib/Ctrl/: Ctrl.c
    ../lib/SCIO/: scio.c
    ../lib/SVPWM/: SVPWM.c
    ../lib/UART/: UART.c
  group HALlib
    ../device/MM32F003_q/HAL_lib/src/: HAL_adc.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group APP
    ../APP/: APP.c
